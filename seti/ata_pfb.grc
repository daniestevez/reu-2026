options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: ata_pfb
    output_language: python
    title: ATA polyphase filterbank demo
  states: {}

blocks:
- name: a0
  id: variable
  parameters:
    value: polyphase_taps[0*num_channels:1*num_channels][::-1]
  states: {}
- name: a1
  id: variable
  parameters:
    value: polyphase_taps[1*num_channels:2*num_channels][::-1]
  states: {}
- name: a2
  id: variable
  parameters:
    value: polyphase_taps[2*num_channels:3*num_channels][::-1]
  states: {}
- name: a3
  id: variable
  parameters:
    value: polyphase_taps[3*num_channels:4*num_channels][::-1]
  states: {}
- name: doppler_drift
  id: variable
  parameters:
    value: '1.5'
  states: {}
- name: duration
  id: variable
  parameters:
    value: '300'
  states: {}
- name: guppi_channels
  id: variable
  parameters:
    value: '192'
  states: {}
- name: num_channels
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: taps_per_channel * num_channels
  states: {}
- name: output_gain
  id: variable
  parameters:
    value: '10'
  states: {}
- name: polyphase_gain
  id: variable
  parameters:
    value: num_channels * np.max(np.sum(polyphase_taps_i32.reshape(-1, num_taps), axis=0))
  states: {}
- name: polyphase_taps
  id: variable
  parameters:
    value: polyphase_taps_i32 / polyphase_gain
  states: {}
- name: polyphase_taps_i32
  id: variable
  parameters:
    value: np.fromfile('ata_pfb_coeffs.i32', 'int32')
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000000'
  states: {}
- name: sawtooth_repeat
  id: variable
  parameters:
    value: '1000'
  states: {}
- name: taps_per_channel
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tone_cn0
  id: variable
  parameters:
    value: '20'
  states: {}
- name: tone_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 123e3
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: 1/num_channels * 3
    freq: 1/duration
    offset: 0.25-0.5/num_channels * 3
    phase: '-np.pi'
    samp_rate: samp_rate / sawtooth_repeat
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_1
  id: analog_sig_source_x
  parameters:
    amp: doppler_drift * duration / (samp_rate / sawtooth_repeat)
    freq: 1/duration
    offset: '0'
    phase: '-np.pi'
    samp_rate: samp_rate / sawtooth_repeat
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '4'
    type: float
    vlen: num_channels
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '128'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_complex_to_interleaved_char_0_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: 128.0 * output_gain
    vector_output: 'False'
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_deinterleave_0_0
  id: blocks_deinterleave
  parameters:
    num_streams: '5'
    type: complex
  states: {}
- name: blocks_delay_0_0_1
  id: blocks_delay
  parameters:
    delay: '2'
    type: float
    vlen: num_channels
  states: {}
- name: blocks_delay_0_1_1
  id: blocks_delay
  parameters:
    delay: '3'
    type: float
    vlen: num_channels
  states: {}
- name: blocks_delay_0_4
  id: blocks_delay
  parameters:
    delay: '1'
    type: float
    vlen: num_channels
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: duration * samp_rate
    type: float
  states: {}
- name: blocks_keep_m_in_n_0_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: guppi_channels
    n: num_channels
    offset: num_channels//4 - guppi_channels//2
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '5'
    n: num_channels
    offset: num_channels//4 - 2
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a3
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a2
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a1
    type: float
    vlen: num_channels
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a0
    type: float
    vlen: num_channels
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sawtooth_repeat
    type: float
  states: {state: disabled}
- name: blocks_repeat_0_0
  id: blocks_repeat
  parameters:
    interp: sawtooth_repeat
    type: complex
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: np.pi / 2
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: num_channels
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: 2 * num_channels
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: 2 * guppi_channels
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate * 0.001
    type: float
  states: {state: bypassed}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vco_c_0
  id: blocks_vco_c
  parameters:
    amplitude: np.sqrt(10**(tone_cn0 / 10) / samp_rate)
    samp_rate: samp_rate / sawtooth_repeat
    sensitivity: 2 * np.pi * samp_rate / sawtooth_repeat
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.1'
    samp_rate: samp_rate
    sensitivity: 2 * np.pi * samp_rate
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: float
    vector: polyphase_taps
  states: {state: disabled}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: num_channels
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: num_channels
    type: complex
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: num_channels
    forward: 'True'
    shift: 'False'
    type: float
    window: '[]'
  states: {}
- name: guppi_guppi_sink_0
  id: guppi_guppi_sink
  parameters:
    az: '0'
    dec: '0'
    filename: test_guppi.0000.raw
    ndim: 2**19
    npol: '1'
    obsbw: samp_rate
    observer: ''
    obsfreq: 1e9 - 0.5*samp_rate/num_channels
    obsnchan: num_channels
    proj_id: ''
    ra: '0'
    src_name: ''
    stt_mjd: '0'
    telescope: ''
    za: '0'
  states: {state: disabled}
- name: guppi_guppi_sink_0_0
  id: guppi_guppi_sink
  parameters:
    az: '0'
    dec: '0'
    filename: guppi.0000.raw
    ndim: 2**19
    npol: '1'
    obsbw: samp_rate / num_channels * guppi_channels
    observer: Daniel Estevez
    obsfreq: 8e9 - 0.5*samp_rate/num_channels
    obsnchan: guppi_channels
    proj_id: '999'
    ra: '0'
    src_name: Simulated source
    stt_mjd: '0'
    telescope: Allen Telescope Array
    za: '0'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import scipy.signal
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/num_channels
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1,1,1
    label: ''
    legend: 'False'
    name: f'Channel {num_channels//4-1}'
    type: complex
    units: ''
  states: {}
- name: qtgui_freq_sink_x_1_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/num_channels
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,2,1,1
    label: ''
    legend: 'False'
    name: f'Channel {num_channels//4}'
    type: complex
    units: ''
  states: {}
- name: qtgui_freq_sink_x_1_2_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/num_channels
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,3,1,1
    label: ''
    legend: 'False'
    name: f'Channel {num_channels//4+1}'
    type: complex
    units: ''
  states: {}
- name: qtgui_freq_sink_x_1_3_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/num_channels
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,4,1,1
    label: ''
    legend: 'False'
    name: f'Channel {num_channels//4+2}'
    type: complex
    units: ''
  states: {}
- name: qtgui_freq_sink_x_1_4
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/num_channels
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,1,1
    label: ''
    legend: 'False'
    name: f'Channel {num_channels//4-2}'
    type: complex
    units: ''
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: num_taps
    srate: '1'
    type: float
  states: {state: disabled}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: pfb_input
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: pfb_input
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: polyphase_out
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_throttle2_0, '0']
- [analog_sig_source_x_0, '0', blocks_repeat_0, '0']
- [analog_sig_source_x_0_1, '0', blocks_vco_c_0, '0']
- [blocks_add_xx_0_0, '0', fft_vxx_0_0, '0']
- [blocks_add_xx_1_0, '0', blocks_head_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_complex_to_interleaved_char_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [blocks_complex_to_real_0, '0', blocks_add_xx_1_0, '1']
- [blocks_deinterleave_0_0, '0', qtgui_freq_sink_x_1_4, '0']
- [blocks_deinterleave_0_0, '1', qtgui_freq_sink_x_1_0_0, '0']
- [blocks_deinterleave_0_0, '2', qtgui_freq_sink_x_1_1_0, '0']
- [blocks_deinterleave_0_0, '3', qtgui_freq_sink_x_1_2_0, '0']
- [blocks_deinterleave_0_0, '4', qtgui_freq_sink_x_1_3_0, '0']
- [blocks_delay_0_0_1, '0', blocks_multiply_const_vxx_0_0_0_1, '0']
- [blocks_delay_0_1_1, '0', blocks_multiply_const_vxx_0_0_0_0_1, '0']
- [blocks_delay_0_4, '0', blocks_multiply_const_vxx_0_0_1, '0']
- [blocks_head_0, '0', virtual_sink_0_0, '0']
- [blocks_keep_m_in_n_0_0_0, '0', blocks_complex_to_interleaved_char_0_0, '0']
- [blocks_keep_m_in_n_0_0_1, '0', blocks_deinterleave_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0_1, '0', blocks_add_xx_0_0, '3']
- [blocks_multiply_const_vxx_0_0_0_1, '0', blocks_add_xx_0_0, '2']
- [blocks_multiply_const_vxx_0_0_1, '0', blocks_add_xx_0_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0_0, '0']
- [blocks_repeat_0, '0', blocks_vco_f_0, '0']
- [blocks_repeat_0_0, '0', blocks_rotator_cc_0, '0']
- [blocks_rotator_cc_0, '0', blocks_complex_to_real_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_delay_0_0_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_delay_0_1_1, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_delay_0_4, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_stream_to_vector_1, '0', guppi_guppi_sink_0, '0']
- [blocks_stream_to_vector_1_0, '0', guppi_guppi_sink_0_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_1_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_vco_c_0, '0', blocks_repeat_0_0, '0']
- [blocks_vco_f_0, '0', blocks_add_xx_1_0, '1']
- [blocks_vector_source_x_0, '0', blocks_throttle2_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_keep_m_in_n_0_0_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_keep_m_in_n_0_0_1, '0']
- [blocks_vector_to_stream_2, '0', blocks_complex_to_interleaved_char_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_1_0, '0']
- [virtual_source_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [virtual_source_3, '0', blocks_vector_to_stream_2, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
