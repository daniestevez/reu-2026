options:
  parameters:
    author: Daniel Estevez
    generate_options: qt_gui
    id: fm_broadcast
    output_language: python
    title: FM broadcast receiver
  states: {}

blocks:
- name: audio_gain
  id: variable_qtgui_entry
  parameters:
    label: Audio gain
    type: real
    value: '0'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '10'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 75e3
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: RF frequency
    type: real
    value: 98.5e6
  states: {}
- name: pll_bw
  id: variable
  parameters:
    value: '5'
  states: {}
- name: pll_range
  id: variable
  parameters:
    value: '10'
  states: {}
- name: rds_decimation
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rds_sps
  id: variable
  parameters:
    value: samp_rate / decimation / rds_decimation / rds_symbol_rate
  states: {}
- name: rds_symbol_rate
  id: variable
  parameters:
    value: '1187.5'
  states: {}
- name: rf_gain
  id: variable_qtgui_entry
  parameters:
    label: RF gain
    type: real
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3_200_000'
  states: {}
- name: taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 0.5 * samp_rate / decimation
    gain: '1.0'
    samp_rate: samp_rate
    width: 0.1 * samp_rate / decimation
    win: window.WIN_HAMMING
  states: {}
- name: tune_freq
  id: variable_qtgui_entry
  parameters:
    label: Tune frequency
    type: real
    value: 300e3
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '3e-2'
    reference: '0.6'
    type: complex
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    comment: Use tau=75e-6 in the US
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0
  id: analog_fm_deemph
  parameters:
    comment: Use tau=75e-6 in the US
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_fm_deemph_0_0_0
  id: analog_fm_deemph
  parameters:
    comment: Use tau=75e-6 in the US
    samp_rate: '48000'
    tau: '50e-6'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: 2 * np.pi * decimation * (19e3 + pll_range) / samp_rate
    min_freq: 2 * np.pi * decimation * (19e3 - pll_range) / samp_rate
    w: 2 * np.pi * decimation * pll_bw / samp_rate
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate / (2 * np.pi * deviation * decimation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/daniel/reu-2024/fm-broadcast/fm_broadcast_recording_20240615.c64
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0_0_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_0_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: audio_gain
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_null_source_0_0_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: '0.01'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.01'
    max_dev: '0.1'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: rds_sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1/round(rds_sps)] * round(rds_sps * 0.5) + [-1/round(rds_sps)] * round(rds_sps * 0.5)'
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: tune_freq
    decim: decimation
    samp_rate: samp_rate
    taps: taps
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 0.5 * samp_rate / decimation / rds_decimation
    decim: rds_decimation
    gain: '1'
    samp_rate: samp_rate / decimation
    type: fir_filter_ccf
    width: 0.1 * samp_rate / decimation / rds_decimation
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decimation
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '17000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate / decimation
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: FM demodulation
  states: {}
- name: note_1
  id: note
  parameters:
    note: Mono audio
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: 19 kHz reference tone
  states: {}
- name: note_2
  id: note
  parameters:
    note: Stereo signal
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: Left/Right audio
  states: {}
- name: note_2_0_0
  id: note
  parameters:
    note: RDS
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 3,1
    name: RDS constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0
    name: RF spectrum
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,1
    name: Spectrum after decimation
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 1,0
    label1: Before lowpass filter
    label2: After lowpass filter
    name: Spectrum after Quadrature Demod
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    gui_hint: 2,0
    label1: In-phase
    label2: Quadrature
    name: Stereo subcarrier spectrum
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_freq_sink_x_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation / rds_decimation
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0
    label1: In-phase
    name: RDS subcarrier spectrum
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 4,1
    name: RDS raster
    ncols: 8 * 13
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 1,1
    name: Audio signal (mono)
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,1
    label1: L + R (mono)
    label2: L - R (stereo signal)
    label3: L
    label4: R
    name: Audio signals
    nconnections: '4'
    size: '1024'
    srate: '48000'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,0
    marker1: '0'
    name: RDS symbols
    size: '100'
    srate: samp_rate
    type: float
    ymax: '3'
    ymin: '-3'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    interp: '48'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    interp: '48'
    type: fff
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: fm_demod
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mono_audio
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: reference_tone
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: stereo_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: reference_tone
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: fm_demod
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: fm_demod
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: fm_demod
  states: {}
- name: virtual_source_0_1_1
  id: virtual_source
  parameters:
    stream_id: mono_audio
  states: {}
- name: virtual_source_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: mono_audio
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: fm_demod
  states: {}
- name: virtual_source_0_3
  id: virtual_source
  parameters:
    stream_id: reference_tone
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: stereo_signal
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: stereo_signal
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_fm_deemph_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_deemph_0, '0', qtgui_time_sink_x_0, '0']
- [analog_fm_deemph_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_deemph_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [analog_fm_deemph_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [analog_fm_deemph_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [analog_pll_refout_cc_0, '0', virtual_sink_2, '0']
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_add_xx_0, '0', analog_fm_deemph_0_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', low_pass_filter_1_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_freq_sink_x_1, '1']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_complex_to_real_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_float_to_complex_0, '0', analog_pll_refout_cc_0, '0']
- [blocks_float_to_complex_0_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [blocks_float_to_complex_0_0_0, '0', blocks_multiply_conjugate_cc_0_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_conjugate_cc_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', audio_sink_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_conjugate_cc_0_0, '1']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_null_source_0_0, '0', blocks_float_to_complex_0_0, '1']
- [blocks_null_source_0_0_0, '0', blocks_float_to_complex_0_0_0, '1']
- [blocks_sub_xx_0, '0', analog_fm_deemph_0_0_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [fir_filter_xxx_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [low_pass_filter_0, '0', fir_filter_xxx_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_1_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0, '1']
- [low_pass_filter_1, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_1_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', analog_fm_deemph_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_1, '0']
- [rational_resampler_xxx_0_0, '0', virtual_sink_3, '0']
- [rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', blocks_multiply_xx_0, '1']
- [virtual_source_0_0, '0', blocks_float_to_complex_0, '0']
- [virtual_source_0_1, '0', low_pass_filter_1, '0']
- [virtual_source_0_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [virtual_source_0_1_0, '0', blocks_float_to_complex_0_0_0, '0']
- [virtual_source_0_1_1, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_1_1_0, '0', blocks_add_xx_0, '0']
- [virtual_source_0_1_1_0, '0', blocks_sub_xx_0, '0']
- [virtual_source_0_2, '0', blocks_float_to_complex_0_0, '0']
- [virtual_source_0_3, '0', blocks_multiply_xx_0_0, '0']
- [virtual_source_0_3, '0', blocks_multiply_xx_0_0, '1']
- [virtual_source_0_3, '0', blocks_multiply_xx_0_0, '2']
- [virtual_source_1, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_1_0, '0', blocks_add_xx_0, '1']
- [virtual_source_1_0, '0', blocks_sub_xx_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
