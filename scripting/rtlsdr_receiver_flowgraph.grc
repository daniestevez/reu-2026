options:
  parameters:
    author: Daniel Estevez
    generate_options: no_gui
    id: rtlsdr_receiver_flowgraph
    output_language: python
    run_options: run
    title: RTL-SDR receiver flowgraph (for scripting)
  states: {}

blocks:
- name: integration_seconds
  id: variable
  parameters:
    value: '1'
  states: {}
- name: integrations
  id: variable
  parameters:
    value: int(np.round(samp_rate / nfft * integration_seconds))
  states: {}
- name: nfft
  id: variable
  parameters:
    value: 2**16
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '3200000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: spectrum_file_output
    type: float
    vlen: nfft
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: round(samp_rate * duration)
    type: complex
  states: {}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: integrations
    type: float
    vlen: nfft
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/integrations] * nfft'
    type: float
    vlen: nfft
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Daniel Estevez
    center_freq: frequency + freq_xlating_frequency
    description: BSRC REU tutorial recording
    filename: iq_file_output
    hw_info: RTL-SDR
    sample_rate: samp_rate / decimation
    type: complex float (fc32_le)
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: decimation
  id: parameter
  parameters:
    label: Decimation factor
    type: intx
    value: '16'
  states: {}
- name: duration
  id: parameter
  parameters:
    label: Observation duration (s)
    type: eng_float
    value: '10'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: nfft
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackman(nfft)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_xlating_frequency
    decim: decimation
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 0.5 * samp_rate / decimation, 0.1 * samp_rate / decimation)
    type: ccc
  states: {}
- name: freq_xlating_frequency
  id: parameter
  parameters:
    label: Frequency Xlating frequency (Hz)
    type: eng_float
    value: 800e3
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: RF frequency (Hz)
    type: eng_float
    value: 98e6
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: iq_file_output
  id: parameter
  parameters:
    label: IQ file output
    type: str
    value: /dev/null
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decimation
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '0'
    freq0: frequency
    gain0: '30'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: spectrum_file_output
  id: parameter
  parameters:
    label: Spectrum file output
    type: str
    value: /dev/null
  states: {}
- name: spectrum_vector_sink
  id: blocks_vector_sink_x
  parameters:
    type: float
    vlen: nfft
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_head_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_head_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_head_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_integrate_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_file_sink_1, '0']
- [blocks_multiply_const_vxx_0, '0', spectrum_vector_sink, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rtlsdr_source_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
